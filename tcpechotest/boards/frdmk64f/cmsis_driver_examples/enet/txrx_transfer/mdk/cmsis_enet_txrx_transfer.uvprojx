# Keil uVision project cmsis_enet_txrx_transfer.uvprojx, settings and files
target cmsis_enet_txrx_transfer debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cmsis_enet_txrx_transfer.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../../components/phy/mdio/enet;../../../../../../components/phy/device/phyksz8081;../../../../../../devices/MK64F12/utilities/debug_console_lite;../../../../../../devices/MK64F12/drivers;../../../../../../devices/MK64F12/cmsis_drivers;../../../../../../devices/MK64F12;../../../../../../components/uart;../../../../../../components/lists;../../../../../../components/phy;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Driver/Include
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
  group source
    ../: cmsis_enet_txrx_transfer.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group mdio
    ../../../../../../components/phy/mdio/enet/: fsl_enet_mdio.h fsl_enet_mdio.c
    ../../../../../../components/phy/: fsl_mdio.h
  group phy
    ../../../../../../components/phy/device/phyksz8081/: fsl_phyksz8081.h fsl_phyksz8081.c
    ../../../../../../components/phy/: fsl_phy.h
  group utilities
    ../../../../../../devices/MK64F12/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../../devices/MK64F12/drivers/: fsl_port.h fsl_sysmpu.h fsl_sysmpu.c fsl_sim.h fsl_sim.c fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_enet.h fsl_enet.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_edma.h fsl_edma.c fsl_dmamux.h fsl_dmamux.c
    ../../../../../../devices/MK64F12/cmsis_drivers/: fsl_enet_cmsis.h fsl_enet_cmsis.c fsl_enet_phy_cmsis.c fsl_enet_phy_cmsis.h
  group device
    ../../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MK64F12/arm/: startup_MK64F12.S
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group CMSIS_driver
    ../../../../../../CMSIS/Driver/Include/: Driver_ETH_MAC.h Driver_ETH.h Driver_Common.h Driver_ETH_PHY.h
target cmsis_enet_txrx_transfer release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: cmsis_enet_txrx_transfer.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM, MCUXPRESSO_SDK
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig) --entry=Reset_Handler
