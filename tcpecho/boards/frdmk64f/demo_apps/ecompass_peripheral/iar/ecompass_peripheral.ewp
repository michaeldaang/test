# IAR project ecompass_peripheral.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FRDM_K64F; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MK64F12/utilities/debug_console_lite; ../../../../../devices/MK64F12/drivers; ../../../../../components/fxos8700cq; ../../../../../devices/MK64F12; ../../../../../components/uart; ../../../../../components/lists; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: ecompass_peripheral.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; PRINTF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FRDM_K64F; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: ecompass_peripheral.c
  group board
    ../: pin_mux.c pin_mux.h peripherals.c peripherals.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../devices/MK64F12/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_port.h fsl_i2c.h fsl_i2c.c fsl_gpio.h fsl_gpio.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_clock.h fsl_clock.c fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h
  group accel
    ../../../../../components/fxos8700cq/: fsl_fxos.h fsl_fxos.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_uart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
